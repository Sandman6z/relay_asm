		ORG 0000H
		AJMP MAIN
		ORG 0100H
			
@ ;MAIN:	MOV A,#01H
@ ;LOOP:	MOV P1.0,A
@ 		;ACALL DELAY
@ 		;RL A
@ 		;AJMP LOOP
		
MAIN:	CLR P1.0
		ACALL DELAY
		ACALL DELAY
		ACALL DELAY		
		SETB P1.0
		ACALL DELAY
		
		
		SJMP MAIN
		
DELAY:	MOV R7,#100
DEL0:	MOV R6,#10
DEL1:	MOV R5,#10
DEL2:	MOV R4,#10
		DJNZ R4,$
		DJNZ R5,DEL2
		DJNZ R6,DEL1
		DJNZ R7,DEL0
		RET
		
		END